Commit message: initial commit

File: src/lelamp_sim/urdf/lelamp.urdf (robot description, URDF)
Before this commit: robot dummy_character_lamp_5dof, 11 links, 10 joints
Joints:
- joint camera_fixed_joint: origin xyz=0.050 0 -0.090 rpy=0 0 0 -> xyz=0.130 0 0 rpy=0 0 0
